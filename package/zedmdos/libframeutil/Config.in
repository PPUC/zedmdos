## package/zedmdos/libframeutil/Config.in
```kconfig
config BR2_PACKAGE_LIBFRAMEUTIL
    bool "libframeutil"

help
      libframeutil - Some DMD frame utilities used by libzedmd and libdmdutil
```
